# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\CORE;.\LIB;.\DRIVE;.\USER
  group CORE
    ./CORE/: STARTUP.A51
  group LIB
    ./LIB/: delay.c uart.c pwm.c
  group DRIVE
    ./DRIVE/: motor.c jdy32.c
  group USER
    ./USER/: main.c
